# Keil uVision project CANDL.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: CANDL
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Source Group 1
    ./: main.cpp main.h setup.cpp
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, CMSIS:RTOS:FreeRTOS 10.3.1, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:STM32Cube HAL:CAN 1.11.1, Device:STM32Cube HAL:Common 1.11.1, Device:STM32Cube HAL:Cortex 1.11.1, Device:STM32Cube HAL:DMA 1.11.1, Device:STM32Cube HAL:GPIO 1.11.1, Device:STM32Cube HAL:PWR 1.11.1, Device:STM32Cube HAL:RCC 1.11.1, Device:STM32Cube HAL:SD 1.11.1, Device:STM32Cube HAL:UART 1.11.1, Device:STM32Cube HAL:USART 1.11.1, Device:STM32Cube LL:Common 1.11.1, Device:STM32Cube LL:EXTI 1.11.1, Device:STM32Cube LL:GPIO 1.11.1, Device:STM32Cube LL:PWR 1.11.1, Device:STM32Cube LL:RCC 1.11.1, Device:STM32Cube LL:RTC 1.11.1, Device:STM32Cube LL:TIM 1.11.1, Device:STM32Cube LL:USART 1.11.1, Device:STM32Cube LL:USB 1.11.1, Device:STM32Cube LL:UTILS 1.11.1, Device:Startup 1.3.1
